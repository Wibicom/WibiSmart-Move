# Keil uVision project Wibeacon.uvprojx, settings and files
target nrf52832 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Wibeacon +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: CONFIG_GPIO_AS_PINRESET BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64  S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  c include: .\SDK\components\softdevice\common\softdevice_handler;.\SDK\components\softdevice\s132\headers;.\SDK\components\softdevice\s132\headers\nrf52;.\SDK\components\toolchain;.\SDK\bsp;.\SDK\external\segger_rtt;.\SDK\config;.\SDK\components\ble\common;.\SDK\components\drivers_nrf\common;.\SDK\components\drivers_nrf\config;.\SDK\components\drivers_nrf\delay;.\SDK\components\drivers_nrf\gpiote;.\SDK\components\drivers_nrf\hal;.\SDK\components\drivers_nrf\uart;.\SDK\components\libraries\button;.\SDK\components\libraries\timer;.\SDK\components\libraries\uart;.\SDK\components\libraries\util;.\SDK\components\drivers_nrf\twi_master;.\SDK\components\drivers_nrf\saadc;.\SDK\components\drivers_nrf\ppi;.\SDK\components\drivers_nrf\timer;..\Wibeacon - ADC;.\SDK\components\drivers_nrf\saadc;.\SDK\components\drivers_nrf\clock;.\SDK\components\ble\ble_services\ble_bas;.\SDK\components\ble\ble_services\ble_dis;.\SDK\components\ble\ble_services\ble_hts;.\SDK\components\drivers_nrf\gpiote;.\SDK\components\drivers_nrf\pstorage;..\Wibeacon - RECOVERY
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
  group Application
    ./: main.c saadc.c flash.c accelerometer.c
  group BLE
    ./SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ./SDK/components/ble/ble_services/ble_bas/: ble_bas.c
    ./SDK/components/ble/ble_services/ble_dis/: ble_dis.c
    ./SDK/components/ble/ble_services/ble_hts/: ble_hts.c
    ./: ble_ads.c ble_ats.c
  group Librairies
    ./SDK/components/libraries/button/: app_button.c
    ./SDK/components/libraries/uart/: retarget.c
    ./SDK/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c
    ./SDK/components/libraries/timer/: app_timer.c
  group SoftDevice
    ./SDK/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group Drivers
    ./SDK/components/libraries/uart/: app_uart.c
    ./SDK/components/drivers_nrf/uart/: nrf_drv_uart.c
    ./SDK/components/drivers_nrf/common/: nrf_drv_common.c
    ./SDK/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ./SDK/components/drivers_nrf/delay/: nrf_delay.c
    ./SDK/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ./SDK/components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ./SDK/components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ./SDK/components/drivers_nrf/timer/: nrf_drv_timer.c
    ./SDK/components/drivers_nrf/hal/: nrf_saadc.c
    ./SDK/components/drivers_nrf/pstorage/: pstorage.c
    ./: bma2x2.c
  group BoardSupport
    ./SDK/bsp/: bsp.c
  group Segger_RTT
    ./SDK/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:Startup 8.6.0
